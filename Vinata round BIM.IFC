Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Vinata BIM.IFC
Time: 2022-08-05T09:28:46
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Vinat Haube rund BIM
In: Default Storey
Material: PC

# IfcBuildingElementProxy: Vinata Gehäuse rund BIM_826501107 VINATA Round - roh
In: Default Storey
Material: Graues Gusseisen

# IfcBuildingElementProxy: Vinata Montagefläche BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Vinata rund Montageblech BIM
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12

# IfcBuildingElementProxy: Vinata rund Ring BIM
In: Default Storey
Material: Graues Gusseisen

# IfcElementAssembly: Vinata BIM
In: Default Storey
PSet_Mass_Property - Mass Measure: 3.18207; Area Measure: 0.947158 m2; Volume Measure: 0.000598544 m3
